require gles-user-module.inc

BRANCH = "1.10/ED5187610"
SRCREV = "3681f88bb4c341709d8c77024b953a24ffd97f05"
