require inc/xt_shared_env.inc

PVRKM_URL = "git://git@gitpct.epam.com/epmd-aepr/pvr_km_vgpu_img.git"
BRANCH = "1.10/ED5187610"
SRCREV = "0958edd060f8dbc8d5cc26c25ff52c4c28463609"
